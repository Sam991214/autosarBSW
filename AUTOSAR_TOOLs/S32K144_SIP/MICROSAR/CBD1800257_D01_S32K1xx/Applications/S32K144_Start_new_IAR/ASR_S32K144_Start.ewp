# IAR project ASR_S32K144_Start.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __ICCARM__; CPU_S32K148; BRS_DERIVATIVE_S32K144; BASIC_RUNTIME_SYSTEM_TYPE_MSR4; DISABLE_WDOG
  ICCARM.CCIncludePath2: BSW\_Common; BSW\BswM; BSW\Can; BSW\CanIf; BSW\CanSM; BSW\CanTp; BSW\CanTrcv_30_Tja1043; BSW\Com; BSW\ComM; BSW\Crc; BSW\Dcm; BSW\Dem; BSW\Det; BSW\Ea; BSW\EcuM; BSW\Eep_30_XXi2c01; BSW\IoHwAb; BSW\Mcal_S32k; BSW\MemIf; BSW\Nm; BSW\NmOsek; BSW\NvM; BSW\Os; BSW\PduR; BSW\RamTst; BSW\vDem42; BSW\VStdLib; BSW\WdgIf; BSW\WdgM; MCAL\Adc_TS_T40D2M10I1R0\include; MCAL\Pwm_TS_T40D2M10I1R0\include; MCAL\Mcl_TS_T40D2M10I1R0\include; MCAL\Base_TS_T40D2M10I1R0\include; MCAL\Dio_TS_T40D2M10I1R0\include; MCAL\Fls_TS_T40D2M10I1R0\include; MCAL\Gpt_TS_T40D2M10I1R0\include; MCAL\Icu_TS_T40D2M10I1R0\include; MCAL\Mcu_TS_T40D2M10I1R0\include; MCAL\Ocu_TS_T40D2M10I1R0\include; MCAL\Port_TS_T40D2M10I1R0\include; MCAL\Spi_TS_T40D2M10I1R0\include; MCAL\Wdg_TS_T40D2M10I1R0\include; Appl\GenData; Appl\GenData\include; Appl\GenData\Components; Appl\Include; Appl\shared\zBrs_AsrEmbeddedRunTimeSystemCfg5; Appl\shared\zBrs_ArmCommon; Appl\shared\zBrs_S32Arm; Device; MCAL\Dio_TS_T40D2M10I1R0\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __ICCARM__; CPU_S32K148; BRS_DERIVATIVE_S32K144; OS_LINK_CODE
  AARM.AUserIncludes: BSW\_Common; BSW\BswM; BSW\Can; BSW\CanIf; BSW\CanSM; BSW\CanTp; BSW\CanTrcv_30_Tja1043; BSW\Com; BSW\ComM; BSW\Crc; BSW\Dcm; BSW\Dem; BSW\Det; BSW\Ea; BSW\EcuM; BSW\Eep_30_XXi2c01; BSW\IoHwAb; BSW\Mcal_S32k; BSW\MemIf; BSW\Nm; BSW\NmOsek; BSW\NvM; BSW\Os; BSW\PduR; BSW\RamTst; BSW\vDem42; BSW\VStdLib; BSW\WdgIf; BSW\WdgM; MCAL\Adc_TS_T40D2M10I1R0\include; MCAL\Base_TS_T40D2M10I1R0\include; MCAL\Dio_TS_T40D2M10I1R0\include; MCAL\Fls_TS_T40D2M10I1R0\include; MCAL\Gpt_TS_T40D2M10I1R0\include; MCAL\Icu_TS_T40D2M10I1R0\include; MCAL\Mcu_TS_T40D2M10I1R0\include; MCAL\Ocu_TS_T40D2M10I1R0\include; MCAL\Port_TS_T40D2M10I1R0\include; MCAL\Spi_TS_T40D2M10I1R0\include; MCAL\Wdg_TS_T40D2M10I1R0\include; Appl\GenData; Appl\GenData\include; Appl\GenData\Components; Appl\Include; Appl\shared\zBrs_AsrEmbeddedRunTimeSystemCfg5; Appl\shared\zBrs_ArmCommon; Appl\shared\zBrs_S32Arm; Device; MCAL\Dio_TS_T40D2M10I1R0\include
  OBJCOPY.OOCOutputFile: ASR_S32K144_Start.srec
  ILINK.IlinkOutputFile: ASR_S32K144_Start.out
  ILINK.IlinkIcfFile: Appl\S32K148Asr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Appl
    Appl/: BrsAsrMain.c S32K148Asr_new.icf
  group Appl/GenData
    Appl/GenData/: BswM_Lcfg.c BswM_PBcfg.c Can_Lcfg.c Can_PBcfg.c CanIf_Lcfg.c CanIf_PBcfg.c CanSM_Lcfg.c CanTp_Lcfg.c CanTp_PBcfg.c Com_Lcfg.c Com_PBcfg.c ComM_Lcfg.c ComM_PBcfg.c Dcm_Lcfg.c Dcm_PBcfg.c Dem_Lcfg.c Dem_PBcfg.c Det_Cfg.c EcuM_Cfg.c EcuM_Init_Cfg.c EcuM_Init_PBcfg.c EcuM_PBcfg.c Os_AccessCheck_Lcfg.c Os_Alarm_Lcfg.c Os_Application_Lcfg.c Os_Barrier_Lcfg.c Os_Core_Lcfg.c Os_Counter_Lcfg.c Os_Error_Lcfg.c Os_Hal_Context_Lcfg.c Os_Hal_Core_Lcfg.c Os_Hal_Entry_Lcfg.c Os_Hal_EntryAsm_Lcfg.asm Os_Hal_Interrupt_Lcfg.c Os_Hal_Kernel_Lcfg.c Os_Hal_MemoryProtection_Lcfg.c Os_Hal_Timer_Lcfg.c Os_Hook_Lcfg.c Os_Ioc_Lcfg.c Os_Isr_Lcfg.c Os_MemoryProtection_Lcfg.c Os_Peripheral_Lcfg.c Os_Resource_Lcfg.c Os_Scheduler_Lcfg.c Os_ScheduleTable_Lcfg.c Os_ServiceFunction_Lcfg.c Os_Spinlock_Lcfg.c Os_Stack_Lcfg.c Os_Task_Lcfg.c Os_TimingProtection_Lcfg.c Os_Trace_Lcfg.c Os_XSignal_Lcfg.c PduR_Lcfg.c PduR_PBcfg.c Rte.c Rte_OsApplication.c Rte_SystemApplication_OsCore0.c
  group Appl/GenData/src
    Appl/GenData/src/: Adc_Cfg.c Adc_PBcfg.c Dio_Cfg.c Gpt_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c Pwm_PBcfg.c Spi_Cfg.c Spi_PBcfg.c
  group Appl/Source
    Appl/Source/: BswM_Callout_Stubs.c CCC_expand.c CddSbc.c CPUload_basic.c CtLedTask.c Dcm_Callout_Stubs.c EcuM_Callout_Stubs.c EMC_expand.c LOCK_basic.c Os_Callout_Stubs.c OsAppTask.c PWL_expand.c Test_SWC.c Test_SWC2.c
  group BSW/BswM
    BSW/BswM/: BswM.c
  group BSW/Can
    BSW/Can/: Can.c Can_Irq.c
  group BSW/CanIf
    BSW/CanIf/: CanIf.c
  group BSW/CanSM
    BSW/CanSM/: CanSM.c
  group BSW/CanTP
    BSW/CanTp/: CanTp.c
  group BSW/CanTrcv_TJA1043
    BSW/CanTrcv_30_Tja1043/: CanTrcv_30_Tja1043.c
  group BSW/Com
    BSW/Com/: Com.c
  group BSW/ComM
    BSW/ComM/: ComM.c
  group BSW/Crc
    BSW/Crc/: Crc.c
  group BSW/Dcm
    BSW/Dcm/: Dcm.c
  group BSW/Dem
    BSW/Dem/: Dem.c
  group BSW/Det
    BSW/Det/: Det.c
  group BSW/Ea
    BSW/Ea/: Ea.c Ea_BlockHandler.c Ea_DatasetHandler.c Ea_EepCoordinator.c Ea_InstanceHandler.c Ea_Layer1_Erase.c Ea_Layer1_Invalidate.c Ea_Layer1_Read.c Ea_Layer1_Write.c Ea_Layer2_InstanceFinder.c Ea_Layer2_InvalidateInstance.c Ea_Layer2_WriteInstance.c Ea_Layer3_ReadManagementBytes.c Ea_PartitionHandler.c Ea_TaskManager.c
  group BSW/EcuM
    BSW/EcuM/: EcuM.c
  group BSW/Eep_30_XXi2c01
    BSW/Eep_30_XXi2c01/: Eep_30_XXi2c01.c Eep_30_XXi2c01_Proc.c
  group BSW/MemIf
    BSW/MemIf/: MemIf.c
  group BSW/Nm
    BSW/Nm/: Nm.c
  group BSW/NmOsek
    BSW/NmOsek/: NmOsek.c
  group BSW/NvM
    BSW/NvM/: NvM.c NvM_Act.c NvM_Crc.c NvM_JobProc.c NvM_Qry.c NvM_Queue.c
  group BSW/Os
    BSW/Os/: Os_AccessCheck.c Os_Alarm.c Os_Application.c Os_Barrier.c Os_Bit.c Os_BitArray.c Os_Core.c Os_Counter.c Os_Deque.c Os_Error.c Os_Event.c Os_Fifo.c Os_Fifo08.c Os_Fifo16.c Os_Fifo32.c Os_FifoRef.c Os_Hal_Compiler_Arm.c Os_Hal_Compiler_Iar.c Os_Hal_Context_v7m.c Os_Hal_ContextAsm.asm Os_Hal_Core.c Os_Hal_Entry.c Os_Hook.c Os_Interrupt.c Os_Ioc.c Os_Isr.c Os_Job.c Os_Lock.c Os_MemoryProtection.c Os_Peripheral.c Os_PriorityQueue.c Os_Resource.c Os_Scheduler.c Os_ScheduleTable.c Os_ServiceFunction.c Os_Spinlock.c Os_Stack.c Os_Task.c Os_Thread.c Os_Timer.c Os_TimingProtection.c Os_Trace.c Os_Trap.c Os_XSignal.c
  group BSW/PduR
    BSW/PduR/: PduR.c PduR_Bm.c PduR_Fm.c PduR_Lock.c PduR_McQ.c PduR_RmIf.c PduR_RmTp.c PduR_RmTp_TxInst.c PduR_Sm.c
  group BSW/RamTst
    BSW/RamTst/: RamTst.c
  group BSW/vDem42
    BSW/vDem42/: vDem42.c
  group BSW/VstdLib
    BSW/VStdLib/: vstdlib.c
  group BSW/WdgIf
    BSW/WdgIf/: WdgIf.c
  group BSW/WdgM
    BSW/WdgM/: WdgM.c WdgM_Checkpoint.c
  group Device
    Device/: startup.c startup_S32K148.s system_S32K148.c
  group MCAL/ADC
    MCAL/Adc_TS_T40D2M10I1R0/src/: Adc.c Adc_Adc12bsarv2.c Adc_Adc12bsarv2_Irq.c Adc_Ipw.c Adc_Pdb.c Adc_Pdb_Irq.c
  group MCAL/DIO
    MCAL/Dio_TS_T40D2M10I1R0/src/: Dio.c Dio_Gpio.c
  group MCAL/GPT
    MCAL/Gpt_TS_T40D2M10I1R0/src/: Gpt.c Gpt_Ftm.c Gpt_Ipw.c Gpt_LPit.c Gpt_Lptmr.c Gpt_SRtc.c
  group MCAL/MCL
    MCAL/Mcl_TS_T40D2M10I1R0/src/: Ftm_Common.c LPit_Common.c Lptmr_Common.c
  group MCAL/MCU
    MCAL/Mcu_TS_T40D2M10I1R0/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group MCAL/PORT
    MCAL/Port_TS_T40D2M10I1R0/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group MCAL/PWM
    MCAL/Pwm_TS_T40D2M10I1R0/src/: Pwm.c Pwm_Ftm.c Pwm_Ipw.c
  group MCAL/SPI
    MCAL/Spi_TS_T40D2M10I1R0/src/: Spi.c Spi_LPspi.c Spi_LPspi_Irq.c
